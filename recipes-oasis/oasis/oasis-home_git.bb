require oasis-ament-python.inc

ROS_CN = "oasis"
ROS_BPN = "oasis_home"
