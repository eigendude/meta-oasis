PACKAGECONFIG_append_oasis = " iptables libatasmart snmp sensors"
